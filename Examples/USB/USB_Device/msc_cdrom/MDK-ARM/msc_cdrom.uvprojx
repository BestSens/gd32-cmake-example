# Keil uVision project msc_cdrom.uvprojx, settings and files
target USBFS_msc_cdrom (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USBFS_msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F450,USE_USB_FS
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\device\class\msc\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\device\core\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\driver\Include;..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\common;..\..\..\..\..\Firmware\GD32F4xx_usb_library\ustd\class\msc;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: app.c flash_data.c flash_msd.c gd32f4xx_hw.c gd32f4xx_it.c usbd_storage_msd.c
  group CMSIS
    ../src/: system_gd32f4xx.c
  group GD32F4xx_EVAL
    ../../../../../Utilities/: gd32f450i_eval.c
  group GD32F4xx_StdPeriph_Driver
    ../../../../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_dma.c gd32f4xx_spi.c gd32f4xx_ctc.c gd32f4xx_fmc.c
  group USB_Drivers
    ../../../../../Firmware/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32F4xx_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../: readme.txt
target USBHS_msc_cdrom (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.1.0
  cpu: as above
  output: USBHS_msc_cdrom +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F450,USE_USB_HS,USE_ULPI_PHY
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.3.0
