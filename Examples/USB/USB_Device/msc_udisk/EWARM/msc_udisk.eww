<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msc_udisk.ewp</path>
  </project>
  <batchBuild/>
</workspace>


