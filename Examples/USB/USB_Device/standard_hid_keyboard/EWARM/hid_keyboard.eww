<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\hid_keyboard.ewp</path>
  </project>
  <batchBuild/>
</workspace>


